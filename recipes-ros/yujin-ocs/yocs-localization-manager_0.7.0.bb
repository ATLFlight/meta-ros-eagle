DESCRIPTION = "Holds the action description and relevant messages for the move_base package"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=6;endline=6;md5=444cab66a04d814ba6a797be308e654b"

DEPENDS = "actionlib-msgs geometry-msgs message-generation roscpp"

require yujin-ocs.inc
