DESCRIPTION = "Holds the action description and relevant messages for the move_base package"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=05f25cf0f3f96a6ceb6c993c949c5392"

DEPENDS = "actionlib actionlib-msgs catkin move-base-msgs nav-msgs yocs-math-toolkit yocs-msgs tf geometry-msgs roscpp visualization-msgs"

require yujin-ocs.inc
