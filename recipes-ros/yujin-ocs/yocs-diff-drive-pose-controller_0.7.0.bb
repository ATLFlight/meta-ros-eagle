DESCRIPTION = "Holds the action description and relevant messages for the move_base package"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=6;endline=6;md5=2634dd23c7f2d54d04ec7589a045cb64"

DEPENDS = "catkin ecl-threads nodelet pluginlib roscpp sensor-msgs tf yocs-controllers yocs-math-toolkit geometry-msgs"

require yujin-ocs.inc
