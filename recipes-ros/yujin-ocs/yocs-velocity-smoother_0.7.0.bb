DESCRIPTION = "Holds the action description and relevant messages for the move_base package"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=945dfbad25e153a2b9eaff80ceee8d68"
DEPENDS = "catkin dynamic-reconfigure ecl-threads geometry-msgs nav-msgs nodelet pluginlib roscpp"
inherit catkin
require yujin-ocs.inc
