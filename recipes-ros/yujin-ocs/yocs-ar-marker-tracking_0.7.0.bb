DESCRIPTION = "Holds the action description and relevant messages for the move_base package"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=6;endline=6;md5=3e6a39cb38485351e0aaa8af221703ec"

DEPENDS = "actionlib-msgs geometry-msgs message-generation roscpp"

require yujin-ocs.inc
