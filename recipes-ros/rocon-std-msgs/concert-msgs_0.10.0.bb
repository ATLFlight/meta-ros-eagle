DESCRIPTION = "ROS: turtlebot"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=10;md5=3f8850318aede4ad4a92576a23cff116"


DEPENDS = "joy std-msgs message-generation message-runtime"

require rocon-std-msgs.inc
