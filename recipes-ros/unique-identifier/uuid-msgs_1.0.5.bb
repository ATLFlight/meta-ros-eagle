SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=0d02810fbb27f481fba959cf729e6610"


DEPENDS = "std-msgs message-generation message-runtime"
inherit catkin
require unique-identifier.inc
