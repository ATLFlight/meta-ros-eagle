SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=afbd0c7393b13c38ed107a60fccdcb18"


DEPENDS = "catkin uuid-msgs unique-id"
inherit catkin
require unique-identifier.inc
