DESCRIPTION = "ROS: turtlebot"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=10;md5=d41d8cd98f00b204e9800998ecf8427e"


DEPENDS = "joy std-msgs message-generation message-runtime"

require rocon-multimaster.inc
