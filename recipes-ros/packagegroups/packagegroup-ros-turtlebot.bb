DESCRIPTION = "ros turtlebot package group"
LICENSE = "MIT"

inherit packagegroup

PACKAGES = "${PN}"

RDEPENDS_${PN} = "\ 
    packagegroup-ros-comm \
    actionlib \
    bond \
    bondcpp \
    bondpy \
    smclib \
    class-loader \
    actionlib-msgs \
    diagnostic-msgs \
    nav-msgs \
    geometry-msgs \
    sensor-msgs \
    shape-msgs \
    stereo-msgs \
    trajectory-msgs \
    visualization-msgs \
    dynamic-reconfigure \
    tf2 \
    tf2-msgs \
    tf2-py \
    tf2-ros \
    tf \
    image-transport \
    nodelet-topic-tools \
    nodelet \
    pluginlib \
    cmake-modules \
    rosconsole-bridge \
    ros-scripts \
    camera-info-manager \
    python-rosdep \
    python-json \
    git \
    python-empy \
    nodelet-core \
    roslint \
    dynamic-reconfigure \
    uuid-msgs \
    urdf \
    urdf-parser-plugin \
    uuid-msgs \
    tf2-kdl \
    tf2-geometry-msgs \
    tf2-kdl \
    tf2-sensor-msgs \
    tf2-tools \
    ecl-build \
    ecl-command-line \
    ecl-concepts \
    ecl-config \
    ecl-console \
    ecl-containers \
    ecl-converters \
    ecl-converters-lite \
    ecl-core-apps \
    ecl-devices \
    ecl-eigen \
    ecl-errors \
    ecl-exceptions \
    ecl-filesystem \
    ecl-formatters \
    ecl-geometry \
    ecl-ipc \
    ecl-license \
    ecl-linear-algebra \
    ecl-math \
    ecl-mobile-robot \
    ecl-mpl \
    ecl-sigslots \
    ecl-sigslots-lite \
    ecl-statistics \
    ecl-streams \
    ecl-threads \
    ecl-time \
    ecl-time-lite \
    ecl-type-traits \
    ecl-utilities \
    xacro \
    create-driver \
    create-node \
    create-description \
    turtlebot-create \
    turtlebot-msgs \
    turtlebot-description \
    turtlebot-bringup \
    turtlebot-capabilities \
    turtlebot \
    turtlebot-teleop \
    kobuki-capabilities \
    kobuki-safety-controller \
    kobuki-controller-tutorial \
    kobuki-rapps \
    kobuki-keyop \
    kobuki-node \
    kobuki-random-walker \
    kobuki-auto-docking \
    kobuki-bumper2pc \
    kobuki \
    kobuki-core \
    kobuki-dock-drive \
    kobuki-driver \
    kobuki-msgs \
    yocs-cmd-vel-mux \
    yocs-controllers \
    yocs-diff-drive-pose-controller \
    yocs-joyop \
    yocs-keyop \
    yocs-localization-manager \
    yocs-math-toolkit \
    yocs-msgs \
    yocs-navigator \
    yocs-rapps \
    yocs-safety-controller \
    yocs-velocity-smoother \
    yocs-virtual-sensor \
    yocs-waypoint-provider \
    yocs-waypoints-navi \
    zeroconf-msgs \
    diagnostic-updater \
    diagnostic-aggregator \
    diagnostic-analysis \
    diagnostic-common-diagnostics \
    rocon-console \
    rocon-ebnf \
    rocon-interactions \
    rocon-launch \
    rocon-master-info \
    rocon-python-comms \
    rocon-python-redis \
    rocon-python-utils \
    rocon-python-wifi \
    rocon-semantic-version \
    rocon-tools \
    rocon-uri \
    rocon-bubble-icons \
    rocon-icons \
    rocon-apps \
    rocon-app-utilities \
    rocon-app-platform \
    rocon-app-manager \
    robot-state-publisher \
    robot-pose-ekf \
    capabilities \
    rocon-std-msgs \
    concert-msgs \
    rocon-std-msgs \
    rocon-service-pair-msgs \
    unique-id \
    rocon-gateway \
    rocon-hub \
    rocon-hub-client \
    rocon-std-msgs \
    rocon-interaction-msgs \
    rocon-app-manager-msgs \
    orocos-kdl \
    pcl-conversions \
    pcl-ros \
    camera-info-manager \
    joy \
    base-local-planner \
    move-base \
    move-base-msgs \
    map-server \
    robot-pose-ekf \
    navfn \
    nav-core \
    turtlebot-teleop \
"
