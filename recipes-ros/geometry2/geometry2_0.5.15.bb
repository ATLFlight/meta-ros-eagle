SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=e838a4f2cec626b8f1f24b8c74f6bd04"

DEPENDS = "catkin cmake_modules "

inherit catkin
require geometry2.inc


