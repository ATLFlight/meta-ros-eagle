SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=6cef6a2a0fb4ff3277953f336436118f"

DEPENDS = "catkin geometry-msgs tf2 actionlib actionlib-msgs message-filters roscpp rosgraph rospy std-msgs tf2-msgs tf2-py xmlrpcpp "

inherit catkin
require geometry2.inc


