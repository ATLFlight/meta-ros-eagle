SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=0c25b61ce792652de939b2e15312f1a6"

DEPENDS = "catkin geometry-msgs tf2-msgs "

inherit catkin
require geometry2.inc


