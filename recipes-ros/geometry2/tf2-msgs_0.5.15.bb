SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=6cef6a2a0fb4ff3277953f336436118f"

DEPENDS = "catkin geometry-msgs actionlib-msgs message-generation "

inherit catkin
require geometry2.inc


