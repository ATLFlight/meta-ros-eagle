DESCRIPTION = "ROS: turtlebot"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=10;md5=3f8850318aede4ad4a92576a23cff116"


DEPENDS = "catkin std-msgs message-generation message-runtime rocon-std-msgs std-msgs uuid-msgs"

require rocon-msgs.inc
